## Kconfig
```kconfig
#
# TSL2561 configuration
#

menu "TSL2561 devices"
	
config  TSL2561
	bool "Enable TSL2561 devices"
	default y

endmenu
```
